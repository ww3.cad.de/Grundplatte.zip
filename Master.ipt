# Autodesk Inventor part: Master
## iProperties
Created: 2010-08
Part Number: Master
Document SubType Name: Modeling
Designer: Admin
Density: 1 g/cm^3
Author: Admin
