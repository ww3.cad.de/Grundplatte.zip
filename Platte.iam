# Autodesk Inventor assembly: Platte
## iProperties
Created: 2010-08
Part Number: Platte
Document SubType Name: Assembly
Designer: Admin
Author: Admin
